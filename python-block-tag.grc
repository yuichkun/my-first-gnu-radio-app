options:
  parameters:
    author: yuichkun
    generate_options: qt_gui
    id: pythonBlockTag
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '3200'
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '128'
    type: float
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    degree: '32'
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, threshold=1.0, report_period=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Threshold Detector',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.threshold = threshold
              self.report_period = report_period
              self.timer = 0
              self.readyForTag = True

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0]

              for index in range(len(input_items[0])):
                  if (input_items[0][index] >= self.threshold and self.readyForTag == True):
                      key = pmt.intern('detect')
                      value = pmt.from_float(np.round(float(input_items[0][index]), 2))
                      writeIndex = self.nitems_written(0) + index
                      self.add_item_tag(0, writeIndex, key, value)
                      self.readyForTag = False

                  if self.readyForTag == False:
                      self.timer += 1

                  if self.timer >= self.report_period:
                      self.timer = 0
                      self.readyForTag = True

              return len(output_items[0])
    report_period: '128'
    threshold: '0.75'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Detection Counter',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samples_since_detection = 0

          def work(self, input_items, output_items):


              tag_tuple = self.get_tags_in_window(0, 0, len(input_items[0]))
              relative_offset_list = []

              for tag in tag_tuple:
                  if pmt.to_python(tag.key) == 'detect':
                      relative_offset_list.append(tag.offset - self.nitems_read(0))

              relative_offset_list.sort()

              for index in range(len(output_items[0])):
                  output_items[0][index] = self.samples_since_detection

                  if (len(relative_offset_list) > 0 and index >= relative_offset_list[0]):
                      relative_offset_list.pop(0)
                      self.samples_since_detection = 0
                  else:
                      self.samples_since_detection = self.samples_since_detection + 1
              return len(output_items[0])
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Threshold Detector
    size: '2048'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Detection Counter
    size: '2048'
    srate: samp_rate
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.05'
    type: float
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}

connections:
- [blocks_add_const_vxx_1, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_1, '0']
- [blocks_repeat_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_tag_gate_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [digital_glfsr_source_x_0, '0', blocks_repeat_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_1, '0', blocks_tag_gate_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
